
PR := "${PR}.2"

RDEPENDS_${PN}_append = " \
	opengles-sgx-530-dev \
	qt4-embedded-staticdev \
	libqt-embeddedopengl4-dev \
	libqt-embeddedopenvg4-dev \
	libqt-embeddedxmlpatterns4-dev \
        "
