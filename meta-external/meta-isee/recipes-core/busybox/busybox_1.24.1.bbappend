FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

PR := "${PR}.1"
