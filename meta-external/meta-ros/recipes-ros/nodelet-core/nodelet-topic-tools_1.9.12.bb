DESCRIPTION = "This package contains common nodelet tools such as a mux, demux and throttle."
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=8;endline=8;md5=76a6cb36a88f0bd16d0304a7e8a97bb2"

DEPENDS = "dynamic-reconfigure"

require nodelet-core.inc
