DESCRIPTION = "This package defines messages commonly used in mapping packages."
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=11;endline=11;md5=a3ae2ba3f0f44e61270955e8cd98afcf"

DEPENDS = "nav-msgs message-generation sensor-msgs std-msgs"

require navigation-msgs.inc
