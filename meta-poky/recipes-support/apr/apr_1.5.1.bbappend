PR := "${PR}.1"

EXTRA_OECONF += "apr_cv_mutex_recursive=yes"
