PR := "${PR}.1"

BOOST_LIBS += "\
	log \
	"
