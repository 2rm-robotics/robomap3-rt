PR := "${PR}.1"

inherit autotools pkgconfig binconfig lib_package
