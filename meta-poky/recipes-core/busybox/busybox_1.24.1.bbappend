FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

PR := "${PR}.4"
