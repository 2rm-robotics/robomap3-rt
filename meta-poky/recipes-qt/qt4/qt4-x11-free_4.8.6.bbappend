QT_WEBKIT ="-no-webkit -no-iconv -nomake demos -nomake examples "
