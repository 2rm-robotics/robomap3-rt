PR := "${PR}.5"

#unset rdepends
RDEPENDS_${PN} = ""
BBCLASSEXTEND = "native nativesdk" 
