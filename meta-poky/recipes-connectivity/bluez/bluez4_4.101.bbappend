FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://typeof.patch;pnum=0 \
"
